# Keil uVision project chenfu.uvproj, settings and files
target chenfu (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: hengsheng_Release_V +hex
  AfterMake: fromelf --bin --output @L.bin "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\05.sys_os;..\05.sys_os\src;..\06.st_driver;..\06.st_driver\00.st_bsp;..\06.st_driver\00.st_bsp\00.mdk;..\06.st_driver\00.st_bsp\01.sys;..\06.st_driver\00.st_bsp\02.driver;..\06.st_driver\00.st_bsp\02.driver\cm3;..\06.st_driver\00.st_bsp\02.driver\inc;..\06.st_driver\00.st_bsp\02.driver\src;..\01.app;..\02.cmm;..\02.cmm\00.type;..\02.cmm\01.queue;..\02.cmm\02.common;..\03.pro;..\03.pro\00.DGUSVPro;..\04.driver;..\04.driver\00.usart;..\04.driver\01.stm32f207bsp;..\04.driver\02.os_bsp;..\04.driver\03.SPIFlash;..\04.driver\04.gpio;..\04.driver\05.rtc;..\04.driver\06.adc;..\04.driver\07.timer;..\03.pro\01.temp;..\04.driver\08.eeprom;..\03.pro\02.MT318Protocol;..\04.driver\09.backup;..\04.driver\10.watchdog;..\08.source;..\08.source\00.gpio_zt;..\03.pro\03.zy
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group 01.app
    ../01.app/: app_cfg.h main.c main.h SMComManager.c SMComManager.h HMI_DW_DATA.c HMI_DW_DATA.h LCDData_DW.c LCDData_DW.h paramConfig.c paramConfig.h ChargerState.c ChargerState.h ChargerState_S.c door_sys_logicCtr_2.c door_sys_logicCtr_2.h CalcChargerTime_2.c CalcChargerTime_2.h CardM1ReaderData.c CardM1ReaderData.h record.c record.h door_sys_logicCtr_ii.c door_sys_logicCtr_ii.h zy_Charger.c zy_Charger.h zy_Charger_Test.c zy_Charger_Test.h lcdData_Voice.c lcdData_Voice.h
  group 02.cmm
    ../02.cmm/00.type/: type.h
    ../02.cmm/01.queue/: queue.h
    ../02.cmm/02.common/: common.c common.h
  group 03.pro
    ../03.pro/00.DGUSVPro/: DGUSVPro.h
    ../03.pro/01.temp/: temp.c temp.h
    ../03.pro/02.MT318Protocol/: MT318Protocol.c MT318Protocol.h
    ../03.pro/03.zy/: zy_Charger_Pro.c zy_Charger_Pro.h
  group 04.driver
    ../04.driver/01.stm32f207bsp/: stm32f207bsp.c stm32f207bsp.h
    ../04.driver/02.os_bsp/: os_bsp.c os_bsp.h
    ../04.driver/03.SPIFlash/: SPIFlash.h
    ../04.driver/05.rtc/: rtc.c rtc.h
    ../04.driver/06.adc/: adc.c adc.h
    ../04.driver/07.timer/: timer.c timer.h
    ../04.driver/08.eeprom/: FM24CL16.h
    ../04.driver/00.usart/: usart.c usart.h
    ../04.driver/09.backup/: backup.h
    ../04.driver/10.watchdog/: watchdog.c watchdog.h
    ../04.driver/04.gpio/: gpio.h
  group 05.sys_os
    ../05.sys_os/: os_cfg.h os_cpu.h ucos_ii.h
    ../05.sys_os/src/: os_core.c os_cpu_a.asm os_cpu_c.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group 06.st_driver
    ../06.st_driver/00.st_bsp/00.mdk/: startup_stm32f2xx.s
    ../06.st_driver/00.st_bsp/01.sys/: system_stm32f2xx.c
    ../06.st_driver/00.st_bsp/02.driver/cm3/: core_cm3.c core_cm3.h
    ../06.st_driver/00.st_bsp/02.driver/inc/: misc.h stm32f2xx.h stm32f2xx_adc.h stm32f2xx_can.h stm32f2xx_conf.h stm32f2xx_crc.h stm32f2xx_dac.h stm32f2xx_dbgmcu.h stm32f2xx_dcmi.h stm32f2xx_dma.h stm32f2xx_exti.h stm32f2xx_flash.h stm32f2xx_fsmc.h stm32f2xx_gpio.h stm32f2xx_hash.h stm32f2xx_i2c.h stm32f2xx_it.h stm32f2xx_iwdg.h stm32f2xx_pwr.h stm32f2xx_rcc.h stm32f2xx_rng.h stm32f2xx_rtc.h stm32f2xx_sdio.h stm32f2xx_spi.h stm32f2xx_syscfg.h stm32f2xx_tim.h stm32f2xx_usart.h stm32f2xx_wwdg.h system_stm32f2xx.h
    ../06.st_driver/00.st_bsp/02.driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group 08.source
    ../08.source/: backup.c ChargerState_Fun.c DGUSVPro.c door_sys_logicCtr_2_Fun.c FM24CL16.c gpio.c HMI_DW_DATA_Fun.c LCDData_DW_Fun.c queue.c SMComManager_Fun.c SPIFlash.c usart1_232.c usart2_485.c usart3_232.c usart4_485.c
